## config/boards/shields/viridikeyboard/Kconfig.shield
```kconfig
config SHIELD_viridikeyboard
    def_bool $(shields_list_contains,viridikeyboard)
```
